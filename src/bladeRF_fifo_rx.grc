options:
  parameters:
    author: Jon Szymaniak <jon.szymaniak@nuand.com>
    category: Custom
    description: RX bladeRF SC16 Q11 samples from a FIFO, convert them to GR Complex values, and write them to a GUI sink.
    generate_options: qt_gui
    id: bladeRF_fifo_rx
    output_language: python
    title: bladeRF FIFO RX
  states: {}

blocks:
- name: frequency_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 1
    label: Frequency
    start: 300e6
    step: 1e6
    stop: 3.8e9
    value: frequency
    widget: counter
  states: {}
- name: sample_rate_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    label: Sample Rate
    start: 160e3
    step: 1e6
    stop: 40e6
    value: sample_rate
    widget: counter
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/viktor/Documents/rir/data/bob_rx1_1GHz_1MHz_-40_20.iqbin
    repeat: 'True'
    type: short
    vlen: '2'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (1.0 / 2048.0)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 10e6
    type: complex
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 1e9
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate_range
    fc: frequency_range
    fftsize: '4096'
    gui_hint: 1, 0, 1, 8
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: '2000000'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
